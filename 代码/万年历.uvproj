# Keil uVision project 万年历.uvproj, settings and files
target Calendar (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: calendar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c STARTUP.A51
